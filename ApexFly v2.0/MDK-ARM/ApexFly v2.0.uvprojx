# Keil uVision project ApexFly v2.0.uvprojx, settings and files
target ApexFly v2.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G474VCTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ApexFly v2_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Modules/De_Bug;../Modules/IMU;../Modules/Motor;../Modules/LED;../Modules/Control;../Modules/Communication;../Modules/Flash;../Modules/Power;../Modules/GPS;../Modules/Mag;../Modules/ToF
  asm include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Modules/De_Bug
    ../Modules/De_Bug/: debug.c debug.h
  group Modules/IMU
    ../Modules/IMU/: mpu6050.c mpu6050.h imu_bias.c imu_bias.h imu_attitude.c imu_attitude.h imu_level.c imu_level.h
  group Modules/Motor
    ../Modules/Motor/: motor.c motor.h motor_test.c motor_test.h
  group Modules/LED
    ../Modules/LED/: led.c led.h
  group Modules/Control
    ../Modules/Control/: mixer.c mixer.h pid.c pid.h cascade_pid.c cascade_pid.h attitude_control.c attitude_control.h pid_table.c pid_table.h vertical_est.c vertical_est.h
  group Modules/Communication
    ../Modules/Communication/: ra01sc.c ra01sc.h apex_protocol.c apex_protocol.h control_link.c control_link.h radio.c radio.h
  group Modules/Flash
    ../Modules/Flash/: w25q64.c w25q64.h blackbox.c blackbox.h
  group Modules/Power
    ../Modules/Power/: battery.c battery.h
  group Modules/GPS
    ../Modules/GPS/: gps_atgm336h.c gps_atgm336h.h gps.c gps.h
  group Modules/Mag
    ../Modules/Mag/: i2c2_lock.c i2c2_lock.h hmc5883l.c hmc5883l.h mag.c mag.h
  group Modules/ToF
    ../Modules/ToF/: vl53l1x.c vl53l1x.h tof.c tof.h
software components: CMSIS:CORE 4.3.0
